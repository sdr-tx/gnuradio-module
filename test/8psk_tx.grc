<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32e3</value></param>
</block>
<block>
<key>Mercurial_SDR</key>
<param><key>id</key><value>Mercurial_SDR_0</value></param>
<param><key>am_fc_5bits_key</key><value>pll_60</value></param>
<param><key>am_fc_6bits_key</key><value>pll_120</value></param>
<param><key>am_fc_7bits_key</key><value>pll_120</value></param>
<param><key>am_fc_8bits_key</key><value>pll_120</value></param>
<param><key>fc_key</key><value>468000</value></param>
<param><key>psk_fc_key</key><value>5000000</value></param>
<param><key>duty_key</key><value>50</value></param>
<param><key>pamtype_key</key><value>linear_key</value></param>
<param><key>modulation_key</key><value>psk</value></param>
<param><key>nbits_key</key><value>8</value></param>
<param><key>fs_key</key><value>32000</value></param>
<param><key>fs_pam_key</key><value>100000</value></param>
<param><key>psk_fs1M_key</key><value>25000</value></param>
<param><key>psk_fs5M_key</key><value>250000</value></param>
<param><key>symtime_key</key><value>500000</value></param>
<param><key>pammethod_key</key><value>natural_key</value></param>
<param><key>psk_key</key><value>8psk</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>4</value></param>
<param><key>type</key><value>int</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_int_to_float</key>
<param><key>id</key><value>blocks_int_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>(0,1,2,3,4,5,6,7)</value></param>
</block>
<connection><source_block_id>Mercurial_SDR_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_int_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_int_to_float_0</source_block_id><sink_block_id>Mercurial_SDR_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>Mercurial_SDR_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_int_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
