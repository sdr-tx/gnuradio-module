<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>Mercurial_SDR</key>
<param><key>id</key><value>Mercurial_SDR_0</value></param>
<param><key>bits_key</key><value>123</value></param>
<param><key>clk_key</key><value>456</value></param>
<param><key>modulation_key</key><value>am</value></param>
<param><key>pamtype_key</key><value></value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>/home/agustin/Descargas/pf/highway_intro.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>Mercurial_SDR_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
