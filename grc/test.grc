<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>Mercurial_SDR</key>
<param><key>id</key><value>Mercurial_SDR_0</value></param>
<param><key>fc_key</key><value>4</value></param>
<param><key>clk_key</key><value>2</value></param>
<param><key>duty_key</key><value>50</value></param>
<param><key>pamtype_key</key><value>ulaw</value></param>
<param><key>modulation_key</key><value>ook</value></param>
<param><key>fs_key</key><value>2</value></param>
<param><key>symtime_key</key><value>500000</value></param>
<param><key>pammethod_key</key><value>flat_key</value></param>
<param><key>psk_key</key><value>8psk</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>Mercurial_SDR_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>Mercurial_SDR_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
